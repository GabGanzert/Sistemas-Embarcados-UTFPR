# IAR project Laboratorio_03.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\WS_IAR_Tiva\TM4C1294_Bare_IAR9-main\TivaWare_C_Series-2.1.4.178; C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\WS_IAR_Tiva\TM4C1294_Bare_IAR9-main\Projects\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Laboratorio_03.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../drivers/: driverleds.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    src/: main.c startup_TM4C1294.s system_TM4C1294_TW.c
