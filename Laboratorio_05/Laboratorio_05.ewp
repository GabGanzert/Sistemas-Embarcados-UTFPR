# IAR project Laboratorio_05.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT
  ICCARM.CCIncludePath2: C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\TM4C1294_RTOS_IAR9-main\TivaWare_C_Series-2.1.4.178; C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\TM4C1294_RTOS_IAR9-main\Projects\drivers; C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\TM4C1294_RTOS_IAR9-main\CMSIS-5.6.0\CMSIS\Core\Include; C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\TM4C1294_RTOS_IAR9-main\CMSIS-5.6.0\CMSIS\RTOS2\Include; C:\Users\Faça\Desktop\EngEletronica\10\SE\Projetos\TM4C1294_RTOS_IAR9-main\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Laboratorio_05.srec
  ILINK.IlinkOutputFile: Laboratorio_05.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../drivers/: driverbuttons.c driverleds.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    src/: main.c RTX_Config.c rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c
    ../../CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/IDE/CM4F/Exe/: RTX_CM.a
